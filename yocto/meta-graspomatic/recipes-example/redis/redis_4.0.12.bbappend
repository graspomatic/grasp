FILESEXTRAPATHS_prepend := "${THISDIR}/redis:"
